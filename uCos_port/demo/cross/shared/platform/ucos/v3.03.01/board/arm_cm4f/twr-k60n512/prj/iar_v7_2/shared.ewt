<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>rkh</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkh.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhassert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhdef.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhevt.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhitl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhmp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhplat.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhrdy.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhrq.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhtim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhtrc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhtype.h</name>
      </file>
    </group>
    <group>
      <name>portable</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\portable\ucos\v3.03.01\rkhport.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\portable\ucos\v3.03.01\rkhport.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\portable\ucos\v3.03.01\rkht.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkh.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhdyn.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhrq.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhsma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhtbl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhtim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhtrc.c</name>
    </file>
  </group>
  <group>
    <name>shared</name>
    <group>
      <name>ucos</name>
      <group>
        <name>APP</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\app.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\app_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\app_hooks.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\cpu_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\includes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\lib_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\os_app_hooks.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\os_app_hooks.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\os_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\os_cfg_app.h</name>
        </file>
      </group>
      <group>
        <name>BSP</name>
        <group>
          <name>Freescale</name>
          <file>
            <name>$PROJ_DIR$\..\..\bsp\Freescale\MK60N512VMD100.h</name>
          </file>
        </group>
        <group>
          <name>OS</name>
          <file>
            <name>$PROJ_DIR$\..\..\bsp\OS\bsp_os.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\bsp\OS\bsp_os.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\bsp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\bsp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\bsp_int.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\bsp_ser.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\bsp_ser.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\IAR\cstartup.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\bsp\IAR\K60X_FLASH.icf</name>
        </file>
      </group>
      <group>
        <name>uC/CPU</name>
        <group>
          <name>ARM-Cortex-M4</name>
          <group>
            <name>IAR</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-CPU\ARM-Cortex-M4\IAR\cpu.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-CPU\ARM-Cortex-M4\IAR\cpu_a.asm</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-CPU\ARM-Cortex-M4\IAR\cpu_c.c</name>
            </file>
          </group>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-CPU\cpu_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-CPU\cpu_core.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-CPU\cpu_def.h</name>
        </file>
      </group>
      <group>
        <name>uC/LIB</name>
        <group>
          <name>Ports</name>
          <group>
            <name>ARM-Cortex-M4</name>
            <group>
              <name>IAR</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\Ports\ARM-Cortex-M4\IAR\lib_mem_a.asm</name>
              </file>
            </group>
          </group>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_ascii.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_ascii.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_math.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_math.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_mem.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_str.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uC-LIB\lib_str.h</name>
        </file>
      </group>
      <group>
        <name>uC/OS-III</name>
        <group>
          <name>Ports</name>
          <group>
            <name>ARM-Cortex-M4</name>
            <group>
              <name>Generic</name>
              <group>
                <name>IAR</name>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR\os_cpu.h</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR\os_cpu_a.asm</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR\os_cpu_c.c</name>
                </file>
              </group>
            </group>
          </group>
        </group>
        <group>
          <name>Source</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_cfg_app.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_dbg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_flag.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_int.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_mem.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_msg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_mutex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_pend_multi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_prio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_q.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_sem.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_stat.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_task.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_tick.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_time.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_tmr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_type.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\micrium\Software\uCOS-III\Source\os_var.c</name>
          </file>
        </group>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cli.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cliact.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cliact.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\rkhcfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\scevt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svract.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svract.h</name>
    </file>
  </group>
</project>


