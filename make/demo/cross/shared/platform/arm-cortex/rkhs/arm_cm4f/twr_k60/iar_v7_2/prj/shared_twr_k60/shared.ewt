<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>bsp</name>
    <group>
      <name>cm4f</name>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\arm_cm4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\arm_cm4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\cpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\derivative.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\MCUinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\MCUinit.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\cm4f\MK60D10.h</name>
      </file>
    </group>
    <group>
      <name>seq</name>
      <file>
        <name>$PROJ_DIR$\..\..\seq\genled.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\mytypes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\seqchbak.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\seqdefs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\seqlog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\seqlog.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\seqtbl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\seqtbl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\sequence.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\seq\sequence.h</name>
      </file>
    </group>
    <group>
      <name>switch</name>
      <file>
        <name>$PROJ_DIR$\..\..\switch\swhdl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\switch\swhdl.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\switch\switch.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\switch\switch.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\bsp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kuart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\kuart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\readme.txt</name>
    </file>
  </group>
  <group>
    <name>rkh</name>
    <group>
      <name>source</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkh.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhassert.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhdef.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhevt.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhitl.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhmp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhplat.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhrdy.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhrq.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhtim.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhtrc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\include\rkhtype.h</name>
        </file>
      </group>
      <group>
        <name>portable</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\portable\arm-cortex\rkhs\arm_cm4f\iar_v7_2\rkhport.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\portable\arm-cortex\rkhs\arm_cm4f\iar_v7_2\rkhport.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\portable\arm-cortex\rkhs\arm_cm4f\iar_v7_2\rkht.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkh.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhdyn.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhrq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhsma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhtbl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhtim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\..\..\..\source\rkhtrc.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>shared</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cli.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cliact.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\cliact.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\rkhcfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\scevt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svract.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\..\..\..\svract.h</name>
    </file>
  </group>
</project>


