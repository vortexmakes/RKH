# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ARM_CM4FIAR7_2__=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\..\..\..\source\include; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\blinky; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\blinky\platform\arm-cortex\rkhs\arm_cm4f\twr_k60\iar_v7_2; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\blinky\platform\arm-cortex\rkhs\arm_cm4f\twr_k60\iar_v7_2\cm4f
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: blinky.srec
  ILINK.IlinkOutputFile: blinky.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group blky
    ../../../../../../../../: bky.c bky.h bkyact.c bkyact.h main.c rkhcfg.h
  group bsp
    ../../: bsp.c bsp.h gpio.h kuart.c kuart.h
  group bsp/cm4f
    ../../cm4f/: arm_cm4.c arm_cm4.h cpu.c cpu.h derivative.h MCUinit.c MCUinit.h MK60D10.h
  group rkh/source
    ../../../../../../../../../../../source/: rkh.c rkhdyn.c rkhmp.c rkhrq.c rkhs.c rkhsma.c rkhtbl.c rkhtim.c rkhtrc.c
  group rkh/source/include
    ../../../../../../../../../../../source/include/: rkh.h rkhassert.h rkhdef.h rkhevt.h rkhitl.h rkhmp.h rkhplat.h rkhrdy.h rkhrq.h rkhs.h rkhtim.h rkhtrc.h rkhtype.h
  group rkh/source/portable
    ../../../../../../../../../../../source/portable/arm-cortex/rkhs/arm_cm4f/iar_v7_2/: rkhport.c rkhport.h rkht.h
