# IAR project shared.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __UCOS_V3_03_01__=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\..\..\..\source\include; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\shared; ..\..\..\..\..\..\..\ucos\v3.03.01; ..\..\..\twr-k60n512\prj\iar_v7_2; ..\..\..\twr-k60n512\bsp; ..\..\..\twr-k60n512\bsp\IAR; ..\..\..\twr-k60n512\bsp\seq; ..\..\..\twr-k60n512\bsp\switch; ..\..\..\twr-k60n512\bsp\OS; ..\..\..\twr-k60n512\bsp\Freescale; ..\..\..\..\..\micrium\Software\uC-CPU; ..\..\..\..\..\micrium\Software\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\micrium\Software\uC-LIB; ..\..\..\..\..\micrium\Software\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\..\..\..\..\micrium\Software\uCOS-III\Source; ..\..\..\..\..\micrium\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: shared.bin
  ILINK.IlinkOutputFile: shared.out
  ILINK.IlinkIcfFile: ..\..\bsp\IAR\K60X_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group rkh
    ../../../../../../../../../../../source/: rkh.c rkhdyn.c rkhmp.c rkhrq.c rkhs.c rkhsma.c rkhtbl.c rkhtim.c rkhtrc.c
  group rkh/include
    ../../../../../../../../../../../source/include/: rkh.h rkhassert.h rkhdef.h rkhevt.h rkhitl.h rkhmp.h rkhplat.h rkhrdy.h rkhrq.h rkhs.h rkhtim.h rkhtrc.h rkhtype.h
  group rkh/portable
    ../../../../../../../../../../../source/portable/ucos/v3.03.01/: rkhport.c rkhport.h rkht.h
  group shared
    ../../../../../../../../: cli.c cli.h cliact.c cliact.h main.c rkhcfg.h scevt.h svr.c svr.h svract.c svract.h
  group shared/platform/ucos
    ./: app_cfg.h lib_cfg.h
    ../../../../../: bsp.c bsp.h cpu_cfg.h includes.h os_cfg.h os_cfg_app.h
  group shared/platform/ucos/twrk60n512
    ../../bsp/: bsp_int.c bsp_twr.c bsp_twr.h gpio.h kuart.c kuart.h
    ../../bsp/IAR/: cstartup.c K60X_FLASH.icf
  group shared/platform/ucos/twrk60n512/Freescale
    ../../bsp/Freescale/: arm_cm4.c arm_cm4.h kinetis.h MK60N512VMD100.h
  group shared/platform/ucos/twrk60n512/OS
    ../../bsp/OS/: bsp_os.c bsp_os.h
  group shared/platform/ucos/twrk60n512/seq
    ../../bsp/seq/: genled.h mytypes.h seqchbak.h seqdefs.h seqlog.c seqlog.h seqtbl.c seqtbl.h sequence.c sequence.h
  group shared/platform/ucos/twrk60n512/switch
    ../../bsp/switch/: swhdl.c swhdl.h switch.c switch.h
  group shared/platform/ucos/uC/CPU
    ../../../../../micrium/Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group shared/platform/ucos/uC/CPU/ARM-Cortex-M4/IAR
    ../../../../../micrium/Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group shared/platform/ucos/uC/LIB
    ../../../../../micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group shared/platform/ucos/uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../../../../micrium/Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group shared/platform/ucos/uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../../../micrium/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group shared/platform/ucos/uC/OS-III/Source
    ../../../../../micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
