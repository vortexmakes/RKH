# IAR project shared.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ARM_CM4FIAR7_2__=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\..\..\..\source\include; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\shared; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\shared\platform\arm-cortex\rkhs\arm_cm4f\twr_k60\iar_v7_2; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\shared\platform\arm-cortex\rkhs\arm_cm4f\twr_k60\iar_v7_2\cm4f; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\shared\platform\arm-cortex\rkhs\arm_cm4f\twr_k60\iar_v7_2\seq; ..\..\..\..\..\..\..\..\..\..\..\demo\cross\shared\platform\arm-cortex\rkhs\arm_cm4f\twr_k60\iar_v7_2\switch
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../../: bsp.c bsp.h gpio.h kuart.c kuart.h readme.txt
  group bsp/cm4f
    ../../cm4f/: arm_cm4.c arm_cm4.h cpu.c cpu.h derivative.h MCUinit.c MCUinit.h MK60D10.h
  group bsp/seq
    ../../seq/: genled.h mytypes.h seqchbak.h seqdefs.h seqlog.c seqlog.h seqtbl.c seqtbl.h sequence.c sequence.h
  group bsp/switch
    ../../switch/: swhdl.c swhdl.h switch.c switch.h
  group rkh/source
    ../../../../../../../../../../../source/: rkh.c rkhdyn.c rkhmp.c rkhrq.c rkhs.c rkhsma.c rkhtbl.c rkhtim.c rkhtrc.c
  group rkh/source/include
    ../../../../../../../../../../../source/include/: rkh.h rkhassert.h rkhdef.h rkhevt.h rkhitl.h rkhmp.h rkhplat.h rkhrdy.h rkhrq.h rkhs.h rkhtim.h rkhtrc.h rkhtype.h
  group rkh/source/portable
    ../../../../../../../../../../../source/portable/arm-cortex/rkhs/arm_cm4f/iar_v7_2/: rkhport.c rkhport.h rkht.h
  group shared
    ../../../../../../../../: cli.c cli.h cliact.c cliact.h main.c rkhcfg.h scevt.h svr.c svr.h svract.c svract.h
